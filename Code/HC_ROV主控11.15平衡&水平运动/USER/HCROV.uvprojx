# Keil uVision project HCROV.uvprojx, settings and files
target HCROV (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PWM +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\HARDWARE\IIC;..\HARDWARE\MS5837;..\HARDWARE\eMPL;..\HARDWARE\EXTI;..\HARDWARE\Send_ypr;..\HARDWARE\rov_pid;..\HARDWARE\timer;..\HARDWARE\motor;..\HARDWARE\system;..\HARDWARE\DataProtocol;..\HARDWARE\W5500;C:\Keil_v5\ARM\ARMCC\include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/IIC/: myiic.c stm32_iic.c
    ../HARDWARE/MS5837/: MS5837.c
    ../HARDWARE/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/Send_ypr/: send_ypr.c
    ../HARDWARE/rov_pid/: Balance_PWM.c
    ../HARDWARE/timer/: Timer.c
    ../HARDWARE/motor/: motor.c
    ../HARDWARE/system/: system.c
    ../HARDWARE/DataProtocol/: DataProtocol.c
    ../HARDWARE/W5500/: W5500.c W5500Control.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_syscfg.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_i2c.c stm32f4xx_adc.c stm32f4xx_exti.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rtc.c stm32f4xx_sdio.c
  group README
    ../: readme.txt
